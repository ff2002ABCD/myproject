# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\project
  group Source Group 1
    ./: main.c Timer0.c Timer0.h Key.c Key.h Delay.c Delay.h
