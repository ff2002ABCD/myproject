# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: 51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\51project
  group Source Group 1
    ./: STARTUP.A51 main.c
