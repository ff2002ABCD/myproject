# Keil uVision project ch375.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: ch375 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CH375.C HOST.C CH375HF4.LIB CH375.H CH375HF4.H
