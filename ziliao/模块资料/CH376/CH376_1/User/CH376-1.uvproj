# Keil uVision project CH376-1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CH376-1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\CH376;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s
  group ch376
    ../CH376/: FILE_SYS.C SPI_Init.C
  group system
    ../SYSTEM/: delay.c sys.c usart.c
  group user
    ./: main_ch376.c
