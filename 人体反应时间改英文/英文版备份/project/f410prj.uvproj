# Keil uVision project f410prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: f410prj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\project
  group Source Group 1
    ./: STARTUP.A51 main.c DISPLCD.c MATHFUN.c f410init.c SPI.c MENU.C KEY.c rsp.c ttl.c WELCOME.c
